# Keil uVision project SLSF4.uvproj, settings and files
target SLSF4 Configuration (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: SLSF4 Configuration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --C99
  c include: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FatFs/src/drivers; ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: main.c bsp_driver_sd.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c fatfs.c main.c bsp_driver_sd.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c fatfs.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c timers.c tasks.c queue.c croutine.c event_groups.c list.c timers.c tasks.c queue.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c heap_4.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2s.c stm32f4xx_hal_sd.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dsi.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_fmc.c stm32f4xx_hal_ltdc.c stm32f4xx_hal.c stm32f4xx_hal_pwr.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_sd.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dsi.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_fmc.c stm32f4xx_hal_ltdc.c stm32f4xx_hal.c stm32f4xx_hal_pwr.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c ff_gen_drv.c ff.c diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c syscall.c ccsbcs.c syscall.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c sd_diskio.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s startup_stm32f429xx.s
